/*
 * Monochrome framebuffer drawing — see gfx.h.
 */

#include "gfx.h"

#include <math.h>
#include <stdlib.h>
#include <string.h>

static int org_x, org_y;

void gfx_set_origin(int dx, int dy)
{
    org_x = dx;
    org_y = dy;
}

void gfx_clear(uint8_t *fb)
{
    memset(fb, 0, GFX_FB_SIZE);
}

void gfx_pixel(uint8_t *fb, int x, int y, int color)
{
    x += org_x;
    y += org_y;
    if (x < 0 || x >= GFX_W || y < 0 || y >= GFX_H) return;
    uint8_t *b = &fb[(y >> 3) * GFX_W + x];
    uint8_t m = 1u << (y & 7);
    if (color == 1)      *b |= m;
    else if (color == 0) *b &= ~m;
    else                 *b ^= m;
}

void gfx_hline(uint8_t *fb, int x, int y, int w, int color)
{
    for (int i = 0; i < w; i++) gfx_pixel(fb, x + i, y, color);
}

void gfx_vline(uint8_t *fb, int x, int y, int h, int color)
{
    for (int i = 0; i < h; i++) gfx_pixel(fb, x, y + i, color);
}

void gfx_hline_dashed(uint8_t *fb, int x, int y, int w, int on, int off)
{
    for (int i = 0; i < w; i++) {
        if (i % (on + off) < on) gfx_pixel(fb, x + i, y, 1);
    }
}

void gfx_rect(uint8_t *fb, int x, int y, int w, int h, int color)
{
    if (w <= 0 || h <= 0) return;
    gfx_hline(fb, x, y, w, color);
    gfx_hline(fb, x, y + h - 1, w, color);
    gfx_vline(fb, x, y + 1, h - 2, color);
    gfx_vline(fb, x + w - 1, y + 1, h - 2, color);
}

void gfx_fill(uint8_t *fb, int x, int y, int w, int h, int color)
{
    for (int j = 0; j < h; j++) gfx_hline(fb, x, y + j, w, color);
}

void gfx_line(uint8_t *fb, int x0, int y0, int x1, int y1, int color)
{
    int dx = abs(x1 - x0), sx = x0 < x1 ? 1 : -1;
    int dy = -abs(y1 - y0), sy = y0 < y1 ? 1 : -1;
    int err = dx + dy;
    for (;;) {
        gfx_pixel(fb, x0, y0, color);
        if (x0 == x1 && y0 == y1) break;
        int e2 = 2 * err;
        if (e2 >= dy) { err += dy; x0 += sx; }
        if (e2 <= dx) { err += dx; y0 += sy; }
    }
}

void gfx_fill_ellipse(uint8_t *fb, int cx, int cy, int rx, int ry, int color)
{
    if (rx <= 0 || ry <= 0) return;
    /* +0.5 on the vertical radius rounds off the single-pixel nubs at
       the top and bottom of small ellipses */
    float k = 1.0f / ((float)ry + 0.5f);
    for (int dy = -ry; dy <= ry; dy++) {
        float u = dy * k;
        int hw = (int)lroundf((float)rx * sqrtf(1.0f - u * u));
        gfx_hline(fb, cx - hw, cy + dy, 2 * hw + 1, color);
    }
}

void gfx_circle(uint8_t *fb, int cx, int cy, int r, int color)
{
    int x = r, y = 0, err = 1 - r;
    while (x >= y) {
        gfx_pixel(fb, cx + x, cy + y, color); gfx_pixel(fb, cx - x, cy + y, color);
        gfx_pixel(fb, cx + x, cy - y, color); gfx_pixel(fb, cx - x, cy - y, color);
        gfx_pixel(fb, cx + y, cy + x, color); gfx_pixel(fb, cx - y, cy + x, color);
        gfx_pixel(fb, cx + y, cy - x, color); gfx_pixel(fb, cx - y, cy - x, color);
        y++;
        if (err < 0) {
            err += 2 * y + 1;
        } else {
            x--;
            err += 2 * (y - x) + 1;
        }
    }
}

/* ------------------------------------------------------------------ */
/*  8x8 font (columns, LSB at the top), printable range 0x20..0x7E    */
/* ------------------------------------------------------------------ */
static const uint8_t font8x8[][8] = {
    /* 0x20 ' ' */ {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    /* 0x21 '!' */ {0x00,0x00,0x06,0x5F,0x5F,0x06,0x00,0x00},
    /* 0x22 '"' */ {0x00,0x03,0x07,0x00,0x00,0x07,0x03,0x00},
    /* 0x23 '#' */ {0x14,0x7F,0x7F,0x14,0x7F,0x7F,0x14,0x00},
    /* 0x24 '$' */ {0x24,0x2E,0x6B,0x6B,0x3A,0x12,0x00,0x00},
    /* 0x25 '%' */ {0x46,0x66,0x30,0x18,0x0C,0x66,0x62,0x00},
    /* 0x26 '&' */ {0x30,0x7A,0x4F,0x5D,0x37,0x7A,0x48,0x00},
    /* 0x27 '\''*/ {0x00,0x04,0x07,0x03,0x00,0x00,0x00,0x00},
    /* 0x28 '(' */ {0x00,0x1C,0x3E,0x63,0x41,0x00,0x00,0x00},
    /* 0x29 ')' */ {0x00,0x41,0x63,0x3E,0x1C,0x00,0x00,0x00},
    /* 0x2A '*' */ {0x08,0x2A,0x3E,0x1C,0x1C,0x3E,0x2A,0x08},
    /* 0x2B '+' */ {0x08,0x08,0x3E,0x3E,0x08,0x08,0x00,0x00},
    /* 0x2C ',' */ {0x00,0x80,0xE0,0x60,0x00,0x00,0x00,0x00},
    /* 0x2D '-' */ {0x08,0x08,0x08,0x08,0x08,0x08,0x00,0x00},
    /* 0x2E '.' */ {0x00,0x00,0x60,0x60,0x00,0x00,0x00,0x00},
    /* 0x2F '/' */ {0x60,0x30,0x18,0x0C,0x06,0x03,0x01,0x00},
    /* 0x30 '0' */ {0x3E,0x7F,0x71,0x59,0x4D,0x7F,0x3E,0x00},
    /* 0x31 '1' */ {0x40,0x42,0x7F,0x7F,0x40,0x40,0x00,0x00},
    /* 0x32 '2' */ {0x62,0x73,0x59,0x49,0x6F,0x66,0x00,0x00},
    /* 0x33 '3' */ {0x22,0x63,0x49,0x49,0x7F,0x36,0x00,0x00},
    /* 0x34 '4' */ {0x18,0x1C,0x16,0x53,0x7F,0x7F,0x50,0x00},
    /* 0x35 '5' */ {0x27,0x67,0x45,0x45,0x7D,0x39,0x00,0x00},
    /* 0x36 '6' */ {0x3C,0x7E,0x4B,0x49,0x79,0x30,0x00,0x00},
    /* 0x37 '7' */ {0x03,0x03,0x71,0x79,0x0F,0x07,0x00,0x00},
    /* 0x38 '8' */ {0x36,0x7F,0x49,0x49,0x7F,0x36,0x00,0x00},
    /* 0x39 '9' */ {0x06,0x4F,0x49,0x69,0x3F,0x1E,0x00,0x00},
    /* 0x3A ':' */ {0x00,0x00,0x36,0x36,0x00,0x00,0x00,0x00},
    /* 0x3B ';' */ {0x00,0x80,0xF6,0x76,0x00,0x00,0x00,0x00},
    /* 0x3C '<' */ {0x08,0x1C,0x36,0x63,0x41,0x00,0x00,0x00},
    /* 0x3D '=' */ {0x24,0x24,0x24,0x24,0x24,0x24,0x00,0x00},
    /* 0x3E '>' */ {0x00,0x41,0x63,0x36,0x1C,0x08,0x00,0x00},
    /* 0x3F '?' */ {0x02,0x03,0x51,0x59,0x0F,0x06,0x00,0x00},
    /* 0x40 '@' */ {0x3E,0x7F,0x41,0x5D,0x5D,0x1F,0x1E,0x00},
    /* 0x41 'A' */ {0x7C,0x7E,0x13,0x13,0x7E,0x7C,0x00,0x00},
    /* 0x42 'B' */ {0x41,0x7F,0x7F,0x49,0x49,0x7F,0x36,0x00},
    /* 0x43 'C' */ {0x1C,0x3E,0x63,0x41,0x41,0x63,0x22,0x00},
    /* 0x44 'D' */ {0x41,0x7F,0x7F,0x41,0x63,0x3E,0x1C,0x00},
    /* 0x45 'E' */ {0x41,0x7F,0x7F,0x49,0x5D,0x41,0x63,0x00},
    /* 0x46 'F' */ {0x41,0x7F,0x7F,0x49,0x1D,0x01,0x03,0x00},
    /* 0x47 'G' */ {0x1C,0x3E,0x63,0x41,0x51,0x73,0x72,0x00},
    /* 0x48 'H' */ {0x7F,0x7F,0x08,0x08,0x7F,0x7F,0x00,0x00},
    /* 0x49 'I' */ {0x00,0x41,0x7F,0x7F,0x41,0x00,0x00,0x00},
    /* 0x4A 'J' */ {0x30,0x70,0x40,0x41,0x7F,0x3F,0x01,0x00},
    /* 0x4B 'K' */ {0x41,0x7F,0x7F,0x08,0x1C,0x77,0x63,0x00},
    /* 0x4C 'L' */ {0x41,0x7F,0x7F,0x41,0x40,0x60,0x70,0x00},
    /* 0x4D 'M' */ {0x7F,0x7F,0x0E,0x1C,0x0E,0x7F,0x7F,0x00},
    /* 0x4E 'N' */ {0x7F,0x7F,0x06,0x0C,0x18,0x7F,0x7F,0x00},
    /* 0x4F 'O' */ {0x1C,0x3E,0x63,0x41,0x63,0x3E,0x1C,0x00},
    /* 0x50 'P' */ {0x41,0x7F,0x7F,0x49,0x09,0x0F,0x06,0x00},
    /* 0x51 'Q' */ {0x1E,0x3F,0x21,0x71,0x7F,0x5E,0x00,0x00},
    /* 0x52 'R' */ {0x41,0x7F,0x7F,0x09,0x19,0x7F,0x66,0x00},
    /* 0x53 'S' */ {0x26,0x6F,0x4D,0x59,0x7B,0x32,0x00,0x00},
    /* 0x54 'T' */ {0x03,0x41,0x7F,0x7F,0x41,0x03,0x00,0x00},
    /* 0x55 'U' */ {0x7F,0x7F,0x40,0x40,0x7F,0x7F,0x00,0x00},
    /* 0x56 'V' */ {0x1F,0x3F,0x60,0x60,0x3F,0x1F,0x00,0x00},
    /* 0x57 'W' */ {0x7F,0x7F,0x30,0x18,0x30,0x7F,0x7F,0x00},
    /* 0x58 'X' */ {0x43,0x67,0x3C,0x18,0x3C,0x67,0x43,0x00},
    /* 0x59 'Y' */ {0x07,0x4F,0x78,0x78,0x4F,0x07,0x00,0x00},
    /* 0x5A 'Z' */ {0x47,0x63,0x71,0x59,0x4D,0x67,0x73,0x00},
    /* 0x5B '[' */ {0x00,0x7F,0x7F,0x41,0x41,0x00,0x00,0x00},
    /* 0x5C '\' */ {0x01,0x03,0x06,0x0C,0x18,0x30,0x60,0x00},
    /* 0x5D ']' */ {0x00,0x41,0x41,0x7F,0x7F,0x00,0x00,0x00},
    /* 0x5E '^' */ {0x08,0x0C,0x06,0x03,0x06,0x0C,0x08,0x00},
    /* 0x5F '_' */ {0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80},
    /* 0x60 '`' */ {0x00,0x00,0x03,0x07,0x04,0x00,0x00,0x00},
    /* 0x61 'a' */ {0x20,0x74,0x54,0x54,0x3C,0x78,0x40,0x00},
    /* 0x62 'b' */ {0x41,0x7F,0x3F,0x48,0x48,0x78,0x30,0x00},
    /* 0x63 'c' */ {0x38,0x7C,0x44,0x44,0x6C,0x28,0x00,0x00},
    /* 0x64 'd' */ {0x30,0x78,0x48,0x49,0x3F,0x7F,0x40,0x00},
    /* 0x65 'e' */ {0x38,0x7C,0x54,0x54,0x5C,0x18,0x00,0x00},
    /* 0x66 'f' */ {0x48,0x7E,0x7F,0x49,0x03,0x02,0x00,0x00},
    /* 0x67 'g' */ {0x98,0xBC,0xA4,0xA4,0xF8,0x7C,0x04,0x00},
    /* 0x68 'h' */ {0x41,0x7F,0x7F,0x08,0x04,0x7C,0x78,0x00},
    /* 0x69 'i' */ {0x00,0x44,0x7D,0x7D,0x40,0x00,0x00,0x00},
    /* 0x6A 'j' */ {0x60,0xE0,0x80,0x80,0xFD,0x7D,0x00,0x00},
    /* 0x6B 'k' */ {0x41,0x7F,0x7F,0x10,0x38,0x6C,0x44,0x00},
    /* 0x6C 'l' */ {0x00,0x41,0x7F,0x7F,0x40,0x00,0x00,0x00},
    /* 0x6D 'm' */ {0x7C,0x7C,0x18,0x38,0x1C,0x7C,0x78,0x00},
    /* 0x6E 'n' */ {0x7C,0x7C,0x04,0x04,0x7C,0x78,0x00,0x00},
    /* 0x6F 'o' */ {0x38,0x7C,0x44,0x44,0x7C,0x38,0x00,0x00},
    /* 0x70 'p' */ {0x84,0xFC,0xF8,0xA4,0x24,0x3C,0x18,0x00},
    /* 0x71 'q' */ {0x18,0x3C,0x24,0xA4,0xF8,0xFC,0x84,0x00},
    /* 0x72 'r' */ {0x44,0x7C,0x78,0x4C,0x04,0x1C,0x18,0x00},
    /* 0x73 's' */ {0x48,0x5C,0x54,0x54,0x74,0x24,0x00,0x00},
    /* 0x74 't' */ {0x00,0x04,0x3E,0x7F,0x44,0x24,0x00,0x00},
    /* 0x75 'u' */ {0x3C,0x7C,0x40,0x40,0x3C,0x7C,0x40,0x00},
    /* 0x76 'v' */ {0x1C,0x3C,0x60,0x60,0x3C,0x1C,0x00,0x00},
    /* 0x77 'w' */ {0x3C,0x7C,0x70,0x38,0x70,0x7C,0x3C,0x00},
    /* 0x78 'x' */ {0x44,0x6C,0x38,0x10,0x38,0x6C,0x44,0x00},
    /* 0x79 'y' */ {0x9C,0xBC,0xA0,0xA0,0xFC,0x7C,0x00,0x00},
    /* 0x7A 'z' */ {0x4C,0x64,0x74,0x5C,0x4C,0x64,0x00,0x00},
    /* 0x7B '{' */ {0x08,0x08,0x3E,0x77,0x41,0x41,0x00,0x00},
    /* 0x7C '|' */ {0x00,0x00,0x00,0x77,0x77,0x00,0x00,0x00},
    /* 0x7D '}' */ {0x41,0x41,0x77,0x3E,0x08,0x08,0x00,0x00},
    /* 0x7E '~' */ {0x02,0x03,0x01,0x03,0x02,0x03,0x01,0x00},
};

int gfx_text(uint8_t *fb, int x, int y, const char *s, int color)
{
    for (; *s; s++) {
        unsigned char c = (unsigned char)*s;
        if (c < 0x20 || c > 0x7E) c = '?';
        const uint8_t *g = font8x8[c - 0x20];
        for (int col = 0; col < 8; col++) {
            for (int row = 0; row < 8; row++) {
                if (g[col] & (1u << row)) gfx_pixel(fb, x + col, y + row, color);
            }
        }
        x += 8;
    }
    return x;
}

int gfx_text_width(const char *s)
{
    return 8 * (int)strlen(s);
}

/* ------------------------------------------------------------------ */
/*  3x5 font: 5 rows of 3 bits (bit 2 = left column)                  */
/* ------------------------------------------------------------------ */

static const char tiny_chars[] =
    " 0123456789.:-+%/<>*!ABCDEFGHIJKLMNOPQRSTUVWXYZ";

static const uint8_t tiny_font[][5] = {
    {0,0,0,0,0},                    /* ' ' */
    {07,05,05,05,07},               /* 0 */
    {02,06,02,02,07},               /* 1 */
    {07,01,07,04,07},               /* 2 */
    {07,01,03,01,07},               /* 3 */
    {05,05,07,01,01},               /* 4 */
    {07,04,07,01,07},               /* 5 */
    {07,04,07,05,07},               /* 6 */
    {07,01,02,02,02},               /* 7 */
    {07,05,07,05,07},               /* 8 */
    {07,05,07,01,07},               /* 9 */
    {0,0,0,0,02},                   /* . */
    {0,02,0,02,0},                  /* : */
    {0,0,07,0,0},                   /* - */
    {0,02,07,02,0},                 /* + */
    {05,01,02,04,05},               /* % */
    {01,01,02,04,04},               /* / */
    {01,02,04,02,01},               /* < */
    {04,02,01,02,04},               /* > */
    {02,05,02,0,0},                 /* * (degree) */
    {02,02,02,0,02},                /* ! */
    {02,05,07,05,05},               /* A */
    {06,05,06,05,06},               /* B */
    {03,04,04,04,03},               /* C */
    {06,05,05,05,06},               /* D */
    {07,04,06,04,07},               /* E */
    {07,04,06,04,04},               /* F */
    {03,04,05,05,03},               /* G */
    {05,05,07,05,05},               /* H */
    {07,02,02,02,07},               /* I */
    {01,01,01,05,02},               /* J */
    {05,05,06,05,05},               /* K */
    {04,04,04,04,07},               /* L */
    {05,07,07,05,05},               /* M */
    {06,05,05,05,05},               /* N */
    {02,05,05,05,02},               /* O */
    {06,05,06,04,04},               /* P */
    {02,05,05,06,03},               /* Q */
    {06,05,06,05,05},               /* R */
    {03,04,02,01,06},               /* S */
    {07,02,02,02,02},               /* T */
    {05,05,05,05,07},               /* U */
    {05,05,05,05,02},               /* V */
    {05,05,07,07,05},               /* W */
    {05,05,02,05,05},               /* X */
    {05,05,02,02,02},               /* Y */
    {07,01,02,04,07},               /* Z */
};

int gfx_tiny(uint8_t *fb, int x, int y, const char *s, int color)
{
    for (; *s; s++) {
        char c = *s;
        if (c >= 'a' && c <= 'z') c = (char)(c - 'a' + 'A');
        const char *p = strchr(tiny_chars, c);
        int idx = (p && c) ? (int)(p - tiny_chars) : 0;
        for (int row = 0; row < 5; row++) {
            for (int col = 0; col < 3; col++) {
                if (tiny_font[idx][row] & (4u >> col)) gfx_pixel(fb, x + col, y + row, color);
            }
        }
        x += 4;
    }
    return x;
}

int gfx_tiny_width(const char *s)
{
    int n = (int)strlen(s);
    return n ? 4 * n - 1 : 0;
}

/* ------------------------------------------------------------------ */
/*  Seven-segment digits                                              */
/* ------------------------------------------------------------------ */

/* Segment bits: a b c d e f g */
static const uint8_t seg_digits[10] = {
    0x3F, 0x06, 0x5B, 0x4F, 0x66, 0x6D, 0x7D, 0x07, 0x7F, 0x6F,
};

static void seg_draw(uint8_t *fb, int x, int y, uint8_t segs, int w, int h, int t)
{
    int mid = y + (h - t) / 2;
    int vh1 = mid - y - t;            /* upper vertical length, between bars */
    int vh2 = (y + h - t) - (mid + t); /* lower vertical length */
    /* Horizontal bars are inset 1 px and verticals stop short of the bars,
       so the segments show the classic small gaps. */
    if (segs & 0x01) gfx_fill(fb, x + 1, y, w - 2, t, 1);                  /* a */
    if (segs & 0x02) gfx_fill(fb, x + w - t, y + t, t, vh1, 1);            /* b */
    if (segs & 0x04) gfx_fill(fb, x + w - t, mid + t, t, vh2, 1);          /* c */
    if (segs & 0x08) gfx_fill(fb, x + 1, y + h - t, w - 2, t, 1);          /* d */
    if (segs & 0x10) gfx_fill(fb, x, mid + t, t, vh2, 1);                  /* e */
    if (segs & 0x20) gfx_fill(fb, x, y + t, t, vh1, 1);                    /* f */
    if (segs & 0x40) gfx_fill(fb, x + 1, mid, w - 2, t, 1);                /* g */
}

static int big_advance(char c, int w, int t)
{
    return c == '.' ? t + 3 : w + 3;
}

int gfx_big(uint8_t *fb, int x, int y, const char *s, int w, int h, int t)
{
    for (; *s; s++) {
        char c = *s;
        if (c >= '0' && c <= '9') {
            seg_draw(fb, x, y, seg_digits[c - '0'], w, h, t);
        } else if (c == '-') {
            seg_draw(fb, x, y, 0x40, w, h, t);
        } else if (c == '.') {
            gfx_fill(fb, x + 1, y + h - t, t, t, 1);
        }
        x += big_advance(c, w, t);
    }
    return x;
}

int gfx_big_width(const char *s, int w, int t)
{
    int x = 0;
    for (; *s; s++) x += big_advance(*s, w, t);
    return x > 0 ? x - 3 : 0;
}

/* ------------------------------------------------------------------ */
/*  ASCII-art sprites                                                 */
/* ------------------------------------------------------------------ */

void gfx_sprite(uint8_t *fb, int x, int y, const char *const *rows,
                int nrows, int scale, int color)
{
    for (int r = 0; r < nrows; r++) {
        for (int c = 0; rows[r][c]; c++) {
            if (rows[r][c] == '#') {
                gfx_fill(fb, x + c * scale, y + r * scale, scale, scale, color);
            }
        }
    }
}
